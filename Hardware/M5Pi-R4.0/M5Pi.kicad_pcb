# Repository imliubo/M5Pi

File README.md:

# M5Pi

M5Pi is an open source Linux embedded development board, using Allwinner F1C200s CPU, and has a beautiful shell.

## Try to use a pre-compiled system image
```shell
wget https://github.com/imliubo/M5Pi/releases/download/v0.1-alpha/M5Pi-sysimage-sdcard-v0.1-alpha.tar.gz
tar -zxvf M5Pi-sysimage-sdcard-v0.1-alpha.tar.gz
dd if=sysimage-sdcard.img of=/dev/sdX  # Please make sure "X" is your TF card mount point.
```

## Try to compile your custom system image

### Install
```shell
sudo apt install wget unzip build-essential git bc swig libncurses-dev libpython3-dev libssl-dev
sudo apt install python3-distutils
```

### Build
```shell
git clone --recursive https://github.com/imliubo/M5Pi
cd M5Pi/buildroot-M5Pi
make IAMLIUBO_m5pi_defconfig  # Use the default config.
make -j ${YOUR_CPU_COUNT}
```

### Build with custom config
```shell
make menuconfig
make uboot-menuconfig
make linux-menuconfig
```

### Flash
```shell
dd if=buildroot-M5Pi/output/images/sysimage-sdcard.img of=/dev/sdX  # Please make sure "X" is your TF card mount point.
```

## License
1. Hardware: CC BY-NC-SA 4.0
2. buildroot-M5Pi: follow the upstream

## Links
[【自 制】这 可 能 是 最 精 致 的 Pi 了【Linux 小主机 | 开 源 | 硬 核】](https://www.bilibili.com/video/BV1RV411W7eH/)

[[开源项目-记录贴]扔掉你手中的开发板，跟我来自制基于F1C100s/F1C200s的M5Pi吧!](https://whycan.com/t_6402.html)

[How-to-make-a-M5Pi](./Tutorials/How-to-make-a-M5Pi.md)

## Thanks to the sponsor Seeed!
Seeed Fusion PCB Assembly Service offers one-stop prototyping for PCB manufacture, PCB assembly and as a result they produce superior quality PCBs and Fast Turnkey PCBA from 7 working days. When you prototype with Seeed Fusion, they can definitely provide Free DFA and Free functional tests for you! Check out their website to know more: https://www.seeedstudio.com/prototype-pcb-assembly.html

## KiCad design Hardware/M5Pi-R4.0/M5Pi.kicad_pcb

File Hardware/README.md:

### CAUTION 

Please use the kicad-nightly version to open the projects.

etc. 
```bash
Version: 6.99.0-unknown-c34fb494b1~148~ubuntu20.04.1, release build
```

Parts:
AE1: Antenna_2.4G; ANT-2.4GHZ-9.5X2.0MM
C1, C2, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C17, C19, C20, C21, C22, C23, C24, C27, C28, C29, C30, C44, C45, C47, C49, C50, C52, C53: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C3, C4, C5, C25, C26, C57: TBD; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C16: 10nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C18: 2.2nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C31, C33, C34, C35, C38, C39: 10uF; C_0603_1608Metric
C32, C36, C37: 20pF; C_0603_1608Metric
C40, C41, C46: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C42, C43: 1uF; C_0603_1608Metric
C48: 100uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C51: 10uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C54, C55: 22uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C56: C_Polarized; CP_EIA-3216-10_Kemet-I
Ci1: TBD; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2, D3: LED; LED_0402_1005Metric
D4: D; D-SMA(DO-214AC)
D5: 1N5819; D_SOD-123
F1: Fuse; Fuse_1206_3216Metric
J1: Micro_SD_Card; MicroSD_Socket_push
J2: Conn_02x15_Odd_Even; PinHeader_2x15_P2.54mm_Vertical
J3: Conn_01x02; PinSocket_1x02_P1.27mm_Vertical
J4: LCD_FPC_10P; TE_1-1734839-0_1x10-1MP_P0.5mm_Horizontal
J5: TOUCH_FPC_8P; TE_0-1734839-8_1x08-1MP_P0.5mm_Horizontal
J6: Speaker; PinHeader_2x01_P2.00mm_Vertical
J11: Grove_Socket_4Pin; Grove_Socket_4Pin_2mm
J12: Conn_01x04; PinSocket_1x04_P1.27mm_Vertical
JP1: Jumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L2, L3: 2.2uH; L_1008_2520Metric
L4: 10uH; L_Sunlord_SWPA4030S_4x4x3mm
Q1: Q_NMOS_GSD; SOT-23
R1: 1K; R_0402_1005Metric
R2: 1.1K; R_0402_1005Metric
R3, R4, R9, R10: 2K2; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R5: 12K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R6, R7, R32, R37: 4.7K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8, R11, R12, R13, R14, R15, R16, R27, R28, R29, R33, R39, R40, R41: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R17, R19, R36: 49K9; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R18: 3K3; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R20: 5.1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21: 680K; R_0402_1005Metric
R22, R24, R25, R26: 150K; R_0402_1005Metric
R23: 470K; R_0402_1005Metric
R30, R31: 200K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R34, R35: TBD; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
Ri1: TBD; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW1, SW2: Button_Tortoise_4Pin; Button_4Pin_Tortoise
TBD1: L; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder
TP1, TP2, TP3, TP4, TP5: TestPoint
U1: CH340E; MSOP-10_3x3mm_P0.5mm
U2: ESP8089; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U3: F1C100s; QFN-88_EP_10x10_Pitch0.4mm
U4: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U5: NS4158B; SOP-8_3.9x4.9mm_P1.27mm
U6, U7, U8: SY8088AAC; SOT-23-5
U9: XC6206P302MR; SOT-23
U10: TP5400; SOP-8_4.8x6.0mm_P1.27mm_EP2.3x3.2mm
UART1: USB_C; USB_C_C393939
Y1: 26Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 24Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C20.1, C21.1, C22.1, C37.1, C39.1, L3.2, R25.1, TP4.1, U3.22 (VDD_CORE), U3.35 (VDD_CORE), U3.71 (VDD_CORE)
+2V5: C23.1, C24.1, C36.1, C38.1, C45.1, L2.2, R9.2, R23.1, TP3.1, U3.30 (VCC_DRAM), U3.31 (VCC_DRAM), U3.32 (VCC_DRAM), U3.34 (VCC_DRAM), U3.36 (VCC_DRAM)
+3V0: C15.2, C43.1, TP5.1, U3.80 (AVCC), U9.2 (VO)
+3V3: C1.1, C6.1, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.1, C17.1, C27.1, C29.2, C30.2, C32.1, C33.1, D1.2 (A), J1.4 (VDD), J2.12, J4.8, J5.1, L1.2, R6.2, R7.2, R11.1, R12.1, R13.2, R14.2, R15.1, R16.2, R17.2, R19.1, R20.1, R21.1, R27.1, R28.1, R29.1, R32.2, R33.2, R36.2, R37.2, R39.2, R40.2, R41.2, TP2.1, U1.10 (V3), U2.1 (VDDA), U2.3 (VDD3P3), U2.4 (VDD3P3), U2.11 (VDDPST), U2.13 (MTDO), U2.15 (GPIO0), U2.17 (VDDPST), U2.29 (VDDD), U2.30 (VDDA), U3.4 (HPVCC), U3.5 (VCC_IO), U3.20 (VCC_IO), U3.50 (VCC_IO), U3.67 (UVCC), U3.73 (TV_VCC), U4.8 (VDDIO), U4.13 (VDD)
+5V: C2.1, C31.1, C34.1, C35.1, C42.1, C48.1, C49.2, C53.1, C56.1, D4.1 (K), D5.1 (K), J2.28, J11.2 (VCC), J12.4, R34.1, TP1.1, U1.7 (VCC), U5.6 (VDD), U6.1 (EN), U6.4 (IN), U7.1 (EN), U7.4 (IN), U8.1 (EN), U8.4 (IN), U9.3 (VI), U10.1 (VOUT)
+5VD: C51.2, D5.2 (A), F1.2, R1.1, U10.5 (VCC)
/AMP_HPL: J2.29, U3.1 (HPL)
/AMP_HPR: Ci1.1, U3.88 (HPR)
/D+: U1.1 (UD+), UART1.A6 (D+)
/D-: U1.2 (UD-), UART1.A7 (D-)
/DM: J2.25, J12.2, U3.68 (USB-DM), UART1.B7 (D-)
/DP: J2.27, J12.1, U3.69 (USB-DP), UART1.B6 (D+)
/I2C0_SCL: J5.4, R6.1, U3.38 (PE11/CLK_OUT/TWI0_SCK/IR_RX/EINTE11), U4.23 (SCL)
/I2C0_SDA: J5.3, R7.1, U3.37 (PE12/DA_MCLK/TWI0_SDA/PWM0/EINTE12), U4.24 (SDA)
/I2C1_SCL: J2.20, J11.4 (IO2), R37.1, U3.11 (PD5/LCD_D7/TWI1_SCK/EINTD5)
/I2C1_SDA: J2.19, J11.3 (IO1), R32.1, U3.12 (PD6/LCD_D10/TWI1_SDA/EINTD6)
/I2C2_SCL: J2.18, U3.23 (PD15/LCD_D21/UART2_RTS/TWI2_SCK/EINTD15)
/I2C2_SDA: J2.17, U3.24 (PD16/LCD_D22/UART2_CTS/TWI2_SDA/EINTD16)
/I2S_BCLK: J2.21, U3.14 (PD8/LCD_D12/DA_BCLK/EINTD8)
/I2S_DIN: J2.26, U3.16 (PD10/LCD_D14/DA_IN/EINTD10)
/I2S_DOUT: J2.23, U3.17 (PD11/LCD_D15/DA_OUT/EINTD11)
/I2S_LRCK: J2.24, U3.15 (PD9/LCD_D13/DA_LRCK/EINTD9)
/I2S_MCLK: J2.22, U3.13 (PD7/LCD_D11/DA_MCLK/EINTD7)
/KEY1: C50.1, R36.1, SW2.1, U3.40 (PE9/CSI_D6/UART2_RTS/SPI1_CLK/EINTE9)
/KEY2: JP1.3 (B), U3.39 (PE10/CSI_D7/UART2_CTS/SPI1_MISO/EINTE10)
/LCD_BL: J4.9, U3.43 (PE6/CSI_D3/PWM1/DA_OUT/OWA_OUT/EINTE6)
/LCD_D/C: J4.7, U3.45 (PE4/CSI_D1/LCD_D16/DA_LRCK/RSB_SDA/EINT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)
/LCD_~RESET: J4.6, J5.6, R20.2, U3.44 (PE5/CSI_D2/LCD_D17/DA_IN/EINTE5)
/MPU_INIT: U3.46 (PE3/CSI_D0/LCD_D9/DA_BCLK/RSB_SCK/EINTE3), U4.12 (INT)
/PD12: J2.8, U3.18 (PD12/LCD_D18/TWI0_SCK/RSB_SCK/EINTD12)
/PD13: J2.2, U3.19 (PD13/LCD_D19/UART2_TX/EINTD13)
/PD14: J2.4, U3.21 (PD14/LCD_D20/UART2_RX/EINTD14)
/PD17: U3.25 (PD17/LCD_D23/OWA_OUT/EINTD17)
/PD18: J2.10, U3.26 (PD18/LCD_CLK/SPI0_CS/EINTD18)
/PD19: J2.7, U3.27 (PD19/LCD_DE/SPI0_MOSI/EINTD19)
/PD20: J2.11, U3.28 (PD20/LCD_HSYNC/SPI0_CLK/EINTD20)
/PD21: J2.9, U3.29 (PD21/LCD_VSYNC/SPI0_MISO/EINTD21)
/SD_CLK: J1.5 (CLK), R13.1, U3.56 (PF2/SDC0_CLK/UART0_RX/EINTF2)
/SD_CMD: J1.3 (CMD), R11.2, U3.55 (PF3/SDC0_CMD/DBG_DO/EINTF3)
/SD_D0: J1.7 (DAT0), R14.1, U3.57 (PF1/SDC0_D0/DBG_DI/EINTF1)
/SD_D1: J1.8 (DAT1), R16.1, U3.58 (PF0/SDC0_D1/DBG_MS/IR_RX/EINTF0)
/SD_D2: J1.1 (DAT2), R15.2, U3.53 (PF5/SDC0_D2/DBG_CK/PWM1/EINTF5)
/SD_D3: J1.2 (DAT3/CD), R12.2, U3.54 (PF4/SDC0_D3/UART0_TX/EINTF4)
/SPI0_CLK: R29.2, U2.21 (SDIO_CLK), U3.59 (PC0/SPI0_CLK/SDC1_CLK)
/SPI0_CS: U2.19 (SDIO_DATA_3), U3.60 (PC1/SPI0_CS/SDC1_CMD)
/SPI0_MISO: U2.22 (SDIO_DATA_0), U3.61 (PC2/SPI0_MISO/SDC1_D0)
/SPI0_MOSI: R28.2, U2.20 (SDIO_CMD), U3.62 (PC3/SPI0_MOSI/UART0_TX)
/SPI1_CLK: J4.4, R39.1, U3.64 (PA2/UART1_RX/SPI1_CLK)
/SPI1_CS: J4.5, R41.1, U3.66 (PA0/UART1_RTS/SPI1_CS)
/SPI1_MISO: J4.3, R40.1, U3.63 (PA3/UART1_TX/SPI1_MISO)
/SPI1_MOSI: J4.2, R33.1, U3.65 (PA1/UART1_CTS/SPI1_MOSI)
/STATUS_LED: Q1.1 (G), R19.2, U3.47 (PE2/CSI_PCLK/LCD_D8/CLK_OUT/EINTE2)
/TOUCH_INT: J5.5, U3.8 (PD2/LCD_D4/UART1_CTS/EINTD2)
/UASRT0_RX: U1.8 (TXD), U3.49 (PE0/CSI_HSYNC/LCD_D0/TWI2_SCK/UART0_RX/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)
/USART0_TX: U1.9 (RXD), U3.48 (PE1/CSI_VSYNC/LCD_D1/TWI2_SDA/UART0_TX/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)
/USART1_RX: J2.13, U3.9 (PD3/LCD_D5/UART1_RX/EINTD3)
/USART1_TX: J2.14, U3.10 (PD4/LCD_D6/UART1_TX/EINTD4)
/USART2_RX: J2.15, U3.41 (PE8/CSI_D5/UART2_RX/SPI1_MOSI/EINTE8)
/USART2_TX: J2.16, U3.42 (PE7/CSI_D4/UART2_TX/SPI1_CS/EINTE7)
/VBAT: C52.1, C54.1, C55.1, J2.30, J3.1, L4.2, U10.6 (BAT)
/WIFI_INT: U2.23 (SDIO_DATA_1), U3.6 (PD0/LCD_D2/TWI0_SDA/RSB_SDA/EINTD0)
/WIFI_RESET: R27.2, U2.7 (CHIP_PU), U3.7 (PD1/LCD_D3/UART1_RTS/EINTD1)
/~RESET: J2.6, JP1.1 (A), U3.70 (~RESET)
GND: C1.2, C2.2, C4.1, C5.1, C6.2, C7.1, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.1, C26.1, C27.2, C28.2, C29.1, C30.1, C31.2, C33.2, C34.2, C35.2, C38.2, C39.2, C40.1, C41.1, C42.2, C43.2, C44.1, C46.1, C47.1, C48.2, C49.1, C50.2, C51.1, C52.2, C53.2, C54.2, C55.2, C56.2, C57.1, J1.0 (SHEILD), J1.6 (VSS), J2.1, J2.3, J2.5, J3.2, J4.1, J4.10, J4.MP (Pin_10), J5.2, J5.MP (Pin_2), J11.1 (GND), J12.3, Q1.3 (D), R2.2, R3.1, R4.2, R5.2, R8.2, R10.1, R22.2, R24.2, R26.2, R30.1, R31.1, R35.1, SW1.2, SW2.2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
unnamed: AE1.FEED, C3.1, C57.2
unnamed: Ci1.2, Ri1.2
unnamed: D1.1 (K), R18.2
unnamed: D2.2 (A), D3.2 (A), R1.2
unnamed: D2.1 (K), U10.2 (~CHRG)
unnamed: D3.1 (K), U10.4 (~STDBY)
unnamed: D4.2 (A), L4.1, U10.8 (LX)
unnamed: J6.1, U5.5 (V0N)
unnamed: J6.2, U5.8 (VOP)
unnamed: C28.1, JP1.2 (C), R17.1, SW1.1
unnamed: Q1.2 (S), R18.1
unnamed: C3.2, TBD1.1, U2.2 (LNA)
unnamed: R5.1, U2.31 (RES12K)
unnamed: C5.2, U2.28 (XTAL_IN), Y1.1
unnamed: C4.2, U2.27 (XTAL_OUT), Y1.3
unnamed: C26.2, U3.51 (HOSCI), Y2.1
unnamed: C25.2, U3.52 (HOSCO), Y2.3
unnamed: C41.2, R31.2, U3.81 (VRA1)
unnamed: C40.2, R30.2, U3.83 (VRA2)
unnamed: C44.2, C45.2, R9.1, R10.2, U3.33 (SVREF)
unnamed: R8.1, U4.9 (AD0)
unnamed: C18.1, U4.20 (CPOUT)
unnamed: C19.1, U4.10 (REGOUT)
unnamed: C46.2, U5.2 (BYPASS)
unnamed: C47.2, R34.2, R35.2, U5.1 (CTRL)
unnamed: Ri1.1, U5.4 (INN)
unnamed: C32.2, R21.2, R22.1, U6.5 (FB)
unnamed: L1.1, U6.3 (LX)
unnamed: C36.2, R23.2, R24.1, U7.5 (FB)
unnamed: L2.1, U7.3 (LX)
unnamed: C37.2, R25.2, R26.1, U8.5 (FB)
unnamed: L3.1, U8.3 (LX)
unnamed: R2.1, U10.3 (PROG)
unnamed: R3.2, UART1.A5 (CC1)
unnamed: R4.1, UART1.B5 (CC2)
VBUS: F1.1, UART1.A4 (VBUS), UART1.A9 (VBUS), UART1.B4 (VBUS), UART1.B9 (VBUS)

Notes on the sheet:
GPIO
I2S
Audio
I2C
UART
CPU Power
USART1
M-BUS
Designer By IAMLIUBO CC BY-NC-ND 4.0
Wi-Fi SPI0
AMP
C113101
RESET KEY & LED
USART2
On Board
USB
LCD SPI1
6V 2A
I2C2
Wi-Fi SPI0
LCD
TF-Card
MPU I2C0
LCD SPI1
Power
SPI
I2C1
CPU
I2C0
VCTRL 0.4VDD - VDD 普通模式 0.9V - 0.4VDD 防失真模式 0 - 0.2V ShutDown

Board: 4 copper layers, 47.5 x 50.0 mm, 141 parts (19 on the bottom side), 99 nets.

## KiCad design Hardware/M5Pi-TYPE-C/M5Pi-TYPE-C.kicad_pcb

Parts:
M5Pi-USB1: USB_C_Receptacle; TYPE-C-31-G
OTG1: USB_C; USB_C_C393939
R1, R2, R5, R6, R7, R8: 0R; R_0402_1005Metric
R3, R4: R; R_0402_1005Metric
UART1: USB_C; USB_C_C393939

Connections:
/OTG_USB_D+: M5Pi-USB1.B6 (D+), OTG1.A6 (D+), OTG1.B6 (D+)
/OTG_USB_D-: M5Pi-USB1.B7 (D-), OTG1.A7 (D-), OTG1.B7 (D-)
/UART_USB_D+: M5Pi-USB1.A6 (D+), UART1.A6 (D+), UART1.B6 (D+)
/UART_USB_D-: M5Pi-USB1.A7 (D-), UART1.A7 (D-), UART1.B7 (D-)
/VBUS: M5Pi-USB1.A4 (VBUS), M5Pi-USB1.A9 (VBUS), M5Pi-USB1.B4 (VBUS), M5Pi-USB1.B9 (VBUS), R5.1, R8.1
GND: M5Pi-USB1.A1 (GND), M5Pi-USB1.A8 (SBU1), M5Pi-USB1.A12 (GND), M5Pi-USB1.B1 (GND), M5Pi-USB1.B8 (SBU2), M5Pi-USB1.B12 (GND), M5Pi-USB1.S1 (SHIELD), OTG1.A1 (GND), OTG1.A8 (SBU1), OTG1.A12 (GND), OTG1.B1 (GND), OTG1.B8 (SBU2), OTG1.B12 (GND), OTG1.S1 (SHIELD), R1.1, R2.1, R3.1, R4.1, R6.1, R7.1, UART1.A1 (GND), UART1.A8 (SBU1), UART1.A12 (GND), UART1.B1 (GND), UART1.B8 (SBU2), UART1.B12 (GND), UART1.S1 (SHIELD)
unnamed: M5Pi-USB1.A5 (CC1), R1.2
unnamed: M5Pi-USB1.B5 (CC2), R2.2
unnamed: OTG1.A4 (VBUS), OTG1.A9 (VBUS), OTG1.B4 (VBUS), OTG1.B9 (VBUS), R8.2
unnamed: OTG1.A5 (CC1), R7.2
unnamed: OTG1.B5 (CC2), R6.2
unnamed: R5.2, UART1.A4 (VBUS), UART1.A9 (VBUS), UART1.B4 (VBUS), UART1.B9 (VBUS)
unnamed: R4.2, UART1.A5 (CC1)
unnamed: R3.2, UART1.B5 (CC2)

Board: 2 copper layers, 18.8 x 32.0 mm, 11 parts (0 on the bottom side), 14 nets.

## Commit log

2021-06-24 v0.1-alpha
2021-07-09 Add M5Pi Launcher submodule
2021-07-10 README: add bilibili video link
2022-01-06 submodule:update buildroot-M5Pi
2022-01-27 PCB: upgrade version 4(NOT TEST)
2022-05-11 Add kicad notes
2024-09-10 Post my blog posts to here

Notices in the files:
Hardware/M5Pi-R4.0/M5Pi.kicad_pcb:
Copyright (C) 2022 IAMLIUBO
